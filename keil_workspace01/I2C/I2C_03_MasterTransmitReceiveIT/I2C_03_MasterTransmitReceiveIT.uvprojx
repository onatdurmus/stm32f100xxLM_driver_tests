# Keil uVision project I2C_03_MasterTransmitReceiveIT.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: I2C_03_MasterTransmitReceiveIT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Drivers\header
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./: main.c
  group drivers_header
    ../../Drivers/header/: stm32f100xxLM_gpio_driver.h stm32f100xxLM_i2c_driver.h stm32f100xxLM_rcc_driver.h stm32F100xxLM_spi_driver.h stm32f100xxLM_usart_driver.h stm32F100xxLMdensity.h
  group drivers_source
    ../../Drivers/source/: stm32f100xxLM_gpio_driver.c stm32f100xxLM_i2c_driver.c stm32f100xxLM_rcc_driver.c stm32f100xxLM_spi_driver.c stm32f100xxLM_usart_driver.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
